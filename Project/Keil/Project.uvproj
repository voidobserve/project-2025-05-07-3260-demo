# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: Demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c misc: interval(3)
  c include: ..\..\Libraries\Include;..\..\User;..\..\Hardware
  asm include: ..\..\Libraries;..\..\Libraries\C51
  group Startup
    ../../Libraries/Startup/: STARTUP.A51
    ../../Libraries/Source/: system.c
  group Hardware
    ../../Hardware/: adc.c timer0.c timer1.c uart0.c timer2.c
  group User
    ../../User/: main.c charge_handle.c ir_handle.c led_handle.c light_handle.c my_debug.c
    ../../Libraries/Source/: debug.c
